# Keil uVision project FlashRam.uvprojx, settings and files
target FlashRam (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: EFM32HG350F64 Silicon Labs
  pack: SiliconLabs.GeckoPlatform_EFM32HG_DFP.2.7.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x00000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: FlashRam +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  AfterMake: C:\FlashRam\generate.bat
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: .\FlashRam.sct
  group EFR32_EFM32
    ./: buffer.c var.c startup_efm32lg.s FlashRam.c
